# Keil uVision project Computer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Computer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware\inc;..\computer_51
  group Source Group 1
    ./: STARTUP.A51 main.c
  group Hardware
    ./Hardware/src/: bsp_lcd1603.c bsp_borard.c bsp_computer.c bsp_clock.c
